# Keil uVision project FM33LC0XX_Detector.uvprojx, settings and files
target debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: FM33LC01X FMSH
  pack: Keil.FM33LC0XX_DFP.1.0.4
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: FM33XX_Detector +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: FM33LC0XX,USE_FULL_ASSERT,__DEBUG
  c include: ..\Drivers\CMSIS\Inculde;..\Drivers\FM33LC0xx_LL_Driver\Inc;..\Drivers\CMSIS\Device\FM\FM33xx\Include;..\MF-config\Inc;..\main;..\Timer_task;..\BSP;..\User_app;..\Inc
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group main
    ../main/: main.c system_config.h
  group User_app
    ../User_app/: up_comming.c up_comming.h power_manage.c power_manage.h task_user.c task_user.h App_process.c App_process.h Protocal.c Protocal.h
  group Task_manage
    ../Timer_task/: task_manage.c task_manage.h
  group User_driver
    ../drv/: crc.c file_bootload.c flash.c interrupt.c uart.c user_init.c drv_rtc.c drv_nbmodule.c timer.c IRDA_Device.c lpuart.c general.c
    D:/automatic/code/drv/: aes.c
  group FM33LC0xx_Driver
    ../Drivers/FM33LC0xx_LL_Driver/Src/: fm33lc0xx_ll_adc.c fm33lc0xx_ll_aes.c fm33lc0xx_ll_atim.c fm33lc0xx_ll_bstim.c fm33lc0xx_ll_comp.c fm33lc0xx_ll_crc.c fm33lc0xx_ll_dma.c fm33lc0xx_ll_flash.c fm33lc0xx_ll_gpio.c fm33lc0xx_ll_gptim.c fm33lc0xx_ll_hdiv.c fm33lc0xx_ll_i2c.c fm33lc0xx_ll_iwdt.c fm33lc0xx_ll_lcd.c fm33lc0xx_ll_lptim.c fm33lc0xx_ll_lpuart.c fm33lc0xx_ll_opa.c fm33lc0xx_ll_pmu.c fm33lc0xx_ll_rcc.c fm33lc0xx_ll_rng.c fm33lc0xx_ll_rtc.c fm33lc0xx_ll_spi.c fm33lc0xx_ll_svd.c fm33lc0xx_ll_u7816.c fm33lc0xx_ll_uart.c fm33lc0xx_ll_wwdt.c
  group CMSIS
    ../Drivers/CMSIS/Device/FM/FM33xx/Source/: system_fm33lc0xx.c
  group MDK-ARM
    ../Drivers/CMSIS/Device/FM/FM33xx/Source/Templates/ARM/: startup_fm33lc0xx.s
  group MF-config
    ../MF-config/Src/: mf_config.c
  group BSP
    ../BSP/: bsp.h bsp.c
target release (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: FM33LC01X FMSH
  pack: Keil.FM33LC0XX_DFP.1.0.4
  cpu: as above
  output: FM33XX_Detector +hex
  AfterMake: MakeFireWare.bat 0x00004000 @L
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: FM33LC0XX,USE_FULL_ASSERT
  c include: ..\Drivers\CMSIS\Inculde;..\Drivers\FM33LC0xx_LL_Driver\Inc;..\Drivers\CMSIS\Device\FM\FM33xx\Include;..\MF-config\Inc;..\Inc;..\main;..\Timer_task;..\BSP;..\User_app
  memory RVCT4: ROM 0x4000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
